## app/tests/utils/testcase.yaml
```yaml
common:
  tags:
    - lib
    - utilities
  platform_allow:
    - native_sim
  integration_platforms:
    - native_sim
tests:
  utilities.debouncer: {}
```
